/**
 * ******************************************************************************
 * @Copyright:  Copyright  (C)  2021-2024 东莞市本末科技有限公司
 * @file 	: libs_crc.c
 * ******************************************************************************
 * @brief 	: the implementation of various CRC functions.
 * @version	: 1.0
 * @date 	: 2024-08-12
 * @note 	: This file provides the core functionality for calculating and verifying CRC checksums.
 * *
 * *
 * ******* 1. Improvement *********
 * * 1. Improved the CRC calculation functions for CRC8, CRC16.
 * *
 * * 2. improvement the function :
 * *
 * *
 * ******* 2. Fix the bug *********
 * * 1. fix the bug of :
 * *
 * *
 * ******* 3. HOW TO USE *********
 * * 0. Include the header file "libs_crc.h" in your project where necessary.
 * * 1. Use the provided functions to calculate, verify, or append CRC values to your data streams.
 * *
 * ******************************************************************************
 */

/* ---------------------------- user header file ---------------------------- */

#include "libs_crc.h"

/* ------------------------ CRC8 function definition ------------------------ */

static const uint8_t g_CRC8_table[256] = {
    0x00, 0x5e, 0xbc, 0xe2, 0x61, 0x3f, 0xdd, 0x83, 0xc2, 0x9c, 0x7e, 0x20, 0xa3, 0xfd, 0x1f, 0x41,
    0x9d, 0xc3, 0x21, 0x7f, 0xfc, 0xa2, 0x40, 0x1e, 0x5f, 0x01, 0xe3, 0xbd, 0x3e, 0x60, 0x82, 0xdc,
    0x23, 0x7d, 0x9f, 0xc1, 0x42, 0x1c, 0xfe, 0xa0, 0xe1, 0xbf, 0x5d, 0x03, 0x80, 0xde, 0x3c, 0x62,
    0xbe, 0xe0, 0x02, 0x5c, 0xdf, 0x81, 0x63, 0x3d, 0x7c, 0x22, 0xc0, 0x9e, 0x1d, 0x43, 0xa1, 0xff,
    0x46, 0x18, 0xfa, 0xa4, 0x27, 0x79, 0x9b, 0xc5, 0x84, 0xda, 0x38, 0x66, 0xe5, 0xbb, 0x59, 0x07,
    0xdb, 0x85, 0x67, 0x39, 0xba, 0xe4, 0x06, 0x58, 0x19, 0x47, 0xa5, 0xfb, 0x78, 0x26, 0xc4, 0x9a,
    0x65, 0x3b, 0xd9, 0x87, 0x04, 0x5a, 0xb8, 0xe6, 0xa7, 0xf9, 0x1b, 0x45, 0xc6, 0x98, 0x7a, 0x24,
    0xf8, 0xa6, 0x44, 0x1a, 0x99, 0xc7, 0x25, 0x7b, 0x3a, 0x64, 0x86, 0xd8, 0x5b, 0x05, 0xe7, 0xb9,
    0x8c, 0xd2, 0x30, 0x6e, 0xed, 0xb3, 0x51, 0x0f, 0x4e, 0x10, 0xf2, 0xac, 0x2f, 0x71, 0x93, 0xcd,
    0x11, 0x4f, 0xad, 0xf3, 0x70, 0x2e, 0xcc, 0x92, 0xd3, 0x8d, 0x6f, 0x31, 0xb2, 0xec, 0x0e, 0x50,
    0xaf, 0xf1, 0x13, 0x4d, 0xce, 0x90, 0x72, 0x2c, 0x6d, 0x33, 0xd1, 0x8f, 0x0c, 0x52, 0xb0, 0xee,
    0x32, 0x6c, 0x8e, 0xd0, 0x53, 0x0d, 0xef, 0xb1, 0xf0, 0xae, 0x4c, 0x12, 0x91, 0xcf, 0x2d, 0x73,
    0xca, 0x94, 0x76, 0x28, 0xab, 0xf5, 0x17, 0x49, 0x08, 0x56, 0xb4, 0xea, 0x69, 0x37, 0xd5, 0x8b,
    0x57, 0x09, 0xeb, 0xb5, 0x36, 0x68, 0x8a, 0xd4, 0x95, 0xcb, 0x29, 0x77, 0xf4, 0xaa, 0x48, 0x16,
    0xe9, 0xb7, 0x55, 0x0b, 0x88, 0xd6, 0x34, 0x6a, 0x2b, 0x75, 0x97, 0xc9, 0x4a, 0x14, 0xf6, 0xa8,
    0x74, 0x2a, 0xc8, 0x96, 0x15, 0x4b, 0xa9, 0xf7, 0xb6, 0xe8, 0x0a, 0x54, 0xd7, 0x89, 0x6b, 0x35};

/**
 * ******************************************************************************
 * @brief 	: Calculate the CRC8 checksum for a given message.
 * @param 	  pchMessage  	: Pointer to the message data.
 * @param 	  dwLength  	: The length of the message data.
 * @param 	  ucCRC8  	: The initial CRC value.
 * @retval 	: The calculated CRC8 value.
 * @author 	: chenningzhan
 * @note 	: None
 * ******************************************************************************
 */
uint8_t crc8_calc(uint8_t *pchMessage, uint32_t dwLength, uint8_t ucCRC8)
{
    uint8_t ucIndex;

    while (dwLength--)
    {
        ucIndex = ucCRC8 ^ (*pchMessage++);
        ucCRC8 = g_CRC8_table[ucIndex];
    }

    return (ucCRC8);
}

/**
 * ******************************************************************************
 * @brief 	: CRC8 Verify function
 * @param 	  pchMessage  	: Data to Verify
 * @param 	  dwLength  	: The total length of the message data including the checksum.
 * @retval 	: True if the checksum is valid, False otherwise.
 * @author 	: chenningzhan
 * @note 	: CRC 的验证方法也可以是看 append 后的字节流经过CRC运算后结果是否为零来判断
 * ******************************************************************************
 */
uint32_t crc8_verify(uint8_t *pchMessage, uint32_t dwLength)
{
    uint8_t ucExpected = 0;

    if ((pchMessage == 0) || (dwLength <= 2))
        return 0;

    ucExpected = crc8_calc(pchMessage, dwLength - 1, CRC8_INIT);

    return (ucExpected == pchMessage[dwLength - 1]);
}

/**
 * ******************************************************************************
 * @brief 	: Append the CRC8 checksum to the end of a message.
 * @param 	  pchMessage  	: Data to CRC and append
 * @param 	  dwLength  	: Stream length = Data + checksum
 * @author 	: chenningzhan
 * @note 	: None
 * ******************************************************************************
 */
void crc8_append(uint8_t *pchMessage, uint32_t dwLength)
{
    uint8_t ucCRC = 0;

    if ((pchMessage == 0) || (dwLength <= 2))
        return;

    ucCRC = crc8_calc((uint8_t *)pchMessage, dwLength - 1, CRC8_INIT);

    pchMessage[dwLength - 1] = ucCRC;
}

/* ------------------------ CRC16 function definition ------------------------ */

/*
**   const variable define
*/
static const uint16_t g_CRC16_table[256] =
    {
        0x0000, 0xc0c1, 0xc181, 0x0140, 0xc301, 0x03c0, 0x0280, 0xc241, 0xc601,
        0x06c0, 0x0780, 0xc741, 0x0500, 0xc5c1, 0xc481, 0x0440, 0xcc01, 0x0cc0,
        0x0d80, 0xcd41, 0x0f00, 0xcfc1, 0xce81, 0x0e40, 0x0a00, 0xcac1, 0xcb81,
        0x0b40, 0xc901, 0x09c0, 0x0880, 0xc841, 0xd801, 0x18c0, 0x1980, 0xd941,
        0x1b00, 0xdbc1, 0xda81, 0x1a40, 0x1e00, 0xdec1, 0xdf81, 0x1f40, 0xdd01,
        0x1dc0, 0x1c80, 0xdc41, 0x1400, 0xd4c1, 0xd581, 0x1540, 0xd701, 0x17c0,
        0x1680, 0xd641, 0xd201, 0x12c0, 0x1380, 0xd341, 0x1100, 0xd1c1, 0xd081,
        0x1040, 0xf001, 0x30c0, 0x3180, 0xf141, 0x3300, 0xf3c1, 0xf281, 0x3240,
        0x3600, 0xf6c1, 0xf781, 0x3740, 0xf501, 0x35c0, 0x3480, 0xf441, 0x3c00,
        0xfcc1, 0xfd81, 0x3d40, 0xff01, 0x3fc0, 0x3e80, 0xfe41, 0xfa01, 0x3ac0,
        0x3b80, 0xfb41, 0x3900, 0xf9c1, 0xf881, 0x3840, 0x2800, 0xe8c1, 0xe981,
        0x2940, 0xeb01, 0x2bc0, 0x2a80, 0xea41, 0xee01, 0x2ec0, 0x2f80, 0xef41,
        0x2d00, 0xedc1, 0xec81, 0x2c40, 0xe401, 0x24c0, 0x2580, 0xe541, 0x2700,
        0xe7c1, 0xe681, 0x2640, 0x2200, 0xe2c1, 0xe381, 0x2340, 0xe101, 0x21c0,
        0x2080, 0xe041, 0xa001, 0x60c0, 0x6180, 0xa141, 0x6300, 0xa3c1, 0xa281,
        0x6240, 0x6600, 0xa6c1, 0xa781, 0x6740, 0xa501, 0x65c0, 0x6480, 0xa441,
        0x6c00, 0xacc1, 0xad81, 0x6d40, 0xaf01, 0x6fc0, 0x6e80, 0xae41, 0xaa01,
        0x6ac0, 0x6b80, 0xab41, 0x6900, 0xa9c1, 0xa881, 0x6840, 0x7800, 0xb8c1,
        0xb981, 0x7940, 0xbb01, 0x7bc0, 0x7a80, 0xba41, 0xbe01, 0x7ec0, 0x7f80,
        0xbf41, 0x7d00, 0xbdc1, 0xbc81, 0x7c40, 0xb401, 0x74c0, 0x7580, 0xb541,
        0x7700, 0xb7c1, 0xb681, 0x7640, 0x7200, 0xb2c1, 0xb381, 0x7340, 0xb101,
        0x71c0, 0x7080, 0xb041, 0x5000, 0x90c1, 0x9181, 0x5140, 0x9301, 0x53c0,
        0x5280, 0x9241, 0x9601, 0x56c0, 0x5780, 0x9741, 0x5500, 0x95c1, 0x9481,
        0x5440, 0x9c01, 0x5cc0, 0x5d80, 0x9d41, 0x5f00, 0x9fc1, 0x9e81, 0x5e40,
        0x5a00, 0x9ac1, 0x9b81, 0x5b40, 0x9901, 0x59c0, 0x5880, 0x9841, 0x8801,
        0x48c0, 0x4980, 0x8941, 0x4b00, 0x8bc1, 0x8a81, 0x4a40, 0x4e00, 0x8ec1,
        0x8f81, 0x4f40, 0x8d01, 0x4dc0, 0x4c80, 0x8c41, 0x4400, 0x84c1, 0x8581,
        0x4540, 0x8701, 0x47c0, 0x4680, 0x8641, 0x8201, 0x42c0, 0x4380, 0x8341,
        0x4100, 0x81c1, 0x8081, 0x4040};

/**
 * ******************************************************************************
 * @brief 	: CRC16 checksum function poly:0x8005
 * @param 	  pchMessage  	: Data to check
 * @param 	  dwLength  	: Stream length
 * @param 	  wCRC  	: initialized checksum
 * @retval 	: CRC checksum
 * @author 	: chenningzhan
 * @note 	: None
 * ******************************************************************************
 */
uint16_t crc16_calc(uint8_t *pchMessage, uint32_t dwLength, uint16_t wCRC)
{
    uint8_t chData;
    if (pchMessage == NULL)
    {
        return 0xFFFF;
    }

    while (dwLength--)
    {
        chData = *pchMessage++;
        (wCRC) = ((uint16_t)(wCRC) >> 8) ^ g_CRC16_table[((uint16_t)(wCRC) ^ (uint16_t)(chData)) & 0x00ff];
    }

    return wCRC;
}

/**
 * ******************************************************************************
 * @brief 	: CRC16 Verify function
 * @param 	  pchMessage  	: Data to Verify
 * @param 	  dwLength  	: 【parameter】
 * @retval 	: True or False (CRC Verify Result)
 * @author 	: chenningzhan
 * @note 	: CRC 的验证方法也可以是看 append 后的字节流经过CRC运算后结果是否为零来判断
 * ******************************************************************************
 */
uint32_t crc16_verify(uint8_t *pchMessage, uint32_t dwLength)
{
    uint16_t wExpected = 0;

    if ((pchMessage == NULL) || (dwLength <= 2))
    {
        return __FALSE;
    }
    wExpected = crc16_calc(pchMessage, dwLength - 2, CRC16_INIT);

    return ((wExpected & 0xff) == pchMessage[dwLength - 2] && ((wExpected >> 8) & 0xff) == pchMessage[dwLength - 1]);
}

/**
 * ******************************************************************************
 * @brief 	: append CRC16 to the end of data
 * @param 	  pchMessage  	: Data to CRC and append
 * @param 	  dwLength  	: Stream length = Data + checksum
 * @author 	: chenningzhan
 * @note 	: None
 * ******************************************************************************
 */
void crc16_append(uint8_t *pchMessage, uint32_t dwLength)
{
    uint16_t wCRC = 0;

    if ((pchMessage == NULL) || (dwLength <= 2))
    {
        return;
    }
    wCRC = crc16_calc((uint8_t *)pchMessage, dwLength - 2, CRC16_INIT);

    pchMessage[dwLength - 2] = (uint8_t)(wCRC & 0x00ff);
    pchMessage[dwLength - 1] = (uint8_t)((wCRC >> 8) & 0x00ff);
}

/* ------------------------ CRC32 function definition ------------------------ */
